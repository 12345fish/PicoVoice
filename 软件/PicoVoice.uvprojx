# Keil uVision project PicoVoice.uvprojx, settings and files
target PicoVoice (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: PicoVoice
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,STM32F030x6,ARM_MATH_CM0
  c include: .\src;.\voice;.\fft;.\drv;.\lib\STM32F0xx_StdPeriph_Driver\inc
  asm define: ARM_MATH_CM0
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c stm32_it.c
  group voice
    ./voice/: voice.c vad.c mfcc.c dtw.c
  group fft
    ./fft/: arm_rfft_init_q15.c arm_rfft_q15.c arm_cfft_q15.c arm_cfft_radix4_q15.c arm_bitreversal2.S arm_const_structs.c arm_common_tables.c
  group drv
    ./drv/: audio_in.c utils.c timebase.c base.h config.h
  group stlib
    ./lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_pwr.c stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_crs.c stm32f0xx_tim.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_dbgmcu.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 1.5.0
